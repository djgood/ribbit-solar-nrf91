## boards/ribbit/ribbit_solar_nrf91/board.yml
```yaml
board:
  name: ribbit_solar_nrf91
  vendor: ribbit
  socs:
  - name: nrf9151
    variants:
    - name: ns
```
